# IAR project slon.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: STR711 ST STR711
  ICCARM.CCDefines: STR711
  ICCARM.CCIncludePath2: Src; ..\scmRTOS\Common; ..\scmRTOS\ARM7
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: STR711
  AARM.AUserIncludes: as above
  XLINK.XclFile: config\STR71x_RAM.xcl
configuration FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: config\STR71x_FLASH.xcl
  group (top)
    Src/: main.cpp
  group scmRTOS
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/ARM7/: OS_Target_asm.s79 OS_Target_cpp.cpp
