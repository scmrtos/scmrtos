# IAR project slon.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2119 Philips LPC2119
  ICCARM.CCDefines: LPC2119
  ICCARM.CCIncludePath2: Src; ..\scmRTOS\Common; ..\scmRTOS\ARM7
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: LPC2119
  AARM.AUserIncludes: as above
  XLINK.XclFile: config\LPC2xxx_RAM.xcl
configuration FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: config\LPC2xxx_FLASH.xcl
  group (top)
    Src/: main.cpp
  group scmRTOS
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/ARM7/: OS_Target_asm.s79 OS_Target_cpp.cpp
