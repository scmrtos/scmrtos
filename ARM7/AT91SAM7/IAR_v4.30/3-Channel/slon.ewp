# IAR project slon.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCDefines: AT91SAM7S64
  ICCARM.CCIncludePath2: Src; ..\scmRTOS\Common; ..\scmRTOS\ARM7
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: AT91SAM7S64
  AARM.AUserIncludes: as above
  XLINK.XclFile: config\AT91SAM7_RAM.xcl
configuration FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: config\AT91SAM7_FLASH.xcl
  group (top)
    Src/: main.cpp
  group scmRTOS
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/ARM7/: OS_Target_asm.s79 OS_Target_cpp.cpp
