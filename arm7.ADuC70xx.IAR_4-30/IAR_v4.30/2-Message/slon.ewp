# IAR project slon.ewp, settings and files
configuration RAM (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: ADuC7020 AnalogDevices ADuC7020
  ICCARM.CCDefines: ADuC7020
  ICCARM.CCIncludePath2: Src; ..\scmRTOS\Common; ..\scmRTOS\ARM7
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ADuC7020
  AARM.AUserIncludes: as above
  XLINK.XclFile: config\ADuC70xx_RAM.xcl
configuration FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: config\ADuC70xx_FLASH.xcl
  group (top)
    Src/: main.cpp
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/ARM7/: OS_Target_asm.s79 OS_Target_cpp.cpp
