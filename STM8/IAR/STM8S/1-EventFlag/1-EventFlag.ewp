# IAR project 1-EventFlag.ewp, settings and files
configuration STM8S105C6 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: F_MASTER=16000000; STM8S105
  ICCSTM8.CCIncludePath2: src\; ..\scmRTOS\Common\; ..\scmRTOS\STM8\; ..\STM8S_StdPeriph_Driver\; ..\STM8S_StdPeriph_Driver\inc\; ..\SamplesCommon\
  ICCSTM8.IccLang: 1
  ASTM8.AsmIncludePath: src
  OBJCOPY.OOCOutputFile: 1-EventFlag.hex
  ILINK.IlinkOutputFile: 1-EventFlag.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: main.cpp
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/STM8/: OS_Target_asm.s OS_Target_cpp.cpp
