# IAR project slon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\scmRTOS\Common\; ..\scmRTOS\CortexM3\; src\; src\fwlib\inc\; src\fwlib\src\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: slon.srec
  ILINK.IlinkOutputFile: slon.out
  ILINK.IlinkIcfFile: src\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Src/: main.cpp scmRTOS_CONFIG.h scmRTOS_TARGET_CFG.h stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
  group scmRTOS/Common
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Kernel.h OS_Services.cpp OS_Services.h scmRTOS.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/CortexM3
    ../scmRTOS/CortexM3/: commdefs.h device.h OS_Target.h OS_Target_asm.s OS_Target_cpp.cpp
