# IAR project slon.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: F169
  ICC430.newCCIncludePaths: Src\; ..\scmRTOS\Common\; ..\scmRTOS\MSP430\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  A430.ADefines: F169
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    Src/: main.cpp
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Services.cpp usrlib.cpp
    ../scmRTOS/MSP430/: OS_Target_asm.s43 OS_Target_cpp.cpp
