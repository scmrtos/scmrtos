# IAR project slon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\scmRTOS\Common\; ..\scmRTOS\CortexM3\; ..\Shared\; src\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\scmRTOS\Common\; ..\scmRTOS\CortexM3\; src\
  OBJCOPY.OOCOutputFile: slon.srec
  ILINK.IlinkOutputFile: slon.out
  ILINK.IlinkIcfFile: ..\Shared\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.AUserIncludes: as above
  group (top)
    Src/: main.cpp scmRTOS_config.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h
  group scmRTOS/Common
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Kernel.h OS_Services.cpp OS_Services.h scmRTOS.h scmRTOS_310_compat.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/CortexM3
    ../scmRTOS/CortexM3/: OS_Target.h OS_Target_asm.s OS_Target_cpp.cpp
  group Shared
    ../Shared/: startup_stm32f10x_md.s SystemInit.c
