# IAR project slon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1766 NXP LPC1766
  ICCARM.CCIncludePath2: ..\scmRTOS\Common\; ..\scmRTOS\CortexM3\; src\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: slon.srec
  ILINK.IlinkOutputFile: slon.out
  ILINK.IlinkIcfFile: src\LPC1766_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: slon.hex
  group (top)
    Src/: cstartup_M.s main.cpp scmRTOS_config.h scmRTOS_TARGET_CFG.h system.cpp
  group scmRTOS/Common
    ../scmRTOS/Common/: OS_Kernel.cpp OS_Kernel.h OS_Services.cpp OS_Services.h scmRTOS.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/CortexM3
    ../scmRTOS/CortexM3/: commdefs.h device.h OS_Target.h OS_Target_asm.s OS_Target_cpp.cpp
